# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L162RD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L162xD
  c include: D:\mbed Shared\en.stm32cubel1\STM32Cube_FW_L1_V1.6.0\Drivers\STM32L1xx_HAL_Driver\Inc;D:\mbed Shared\en.stm32cubel1\STM32Cube_FW_L1_V1.6.0\Drivers\BSP\STM32L1xx_Nucleo;..\ZAP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Inc
    ./: main.h stm32l1xx_hal_conf.h stm32l1xx_it.h my_aes.h serv_port.h serv_port_handlers.h user.h acc_aes.h
  group Src
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c stm32l1xx_hal_msp.c my_aes.c serv_port.c serv_port_handlers.c stm32l1xx_hal_clbk.c user.c acc_aes.c
  group HAL Src
    D:/mbed Shared/en.stm32cubel1/STM32Cube_FW_L1_V1.6.0/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group LL Src
    D:/mbed Shared/en.stm32cubel1/STM32Cube_FW_L1_V1.6.0/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_dma.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_exti.c stm32l1xx_ll_usart.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_tim.c stm32l1xx_ll_gpio.c stm32l1xx_ll_spi.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_i2c.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_comp.c stm32l1xx_ll_adc.c stm32l1xx_ll_rtc.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Security:mbed TLS 2.4.2, Device:Startup 2.0.0
